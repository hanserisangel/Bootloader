# Keil uVision project OTA_Bootloader.uvprojx, settings and files
target OTA_Bootloader (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: OTA_Bootloader +hex
  AfterMake: D:\Keil5\ARM\ARMCC\bin\fromelf.exe --bin -o D:\Keil5\Project\OTA_Update\OTA_Bootloader\MDK-ARM\OTA_Bootloader\OTA_Bootloader.bin D:\Keil5\Project\OTA_Update\OTA_Bootloader\MDK-ARM\OTA_Bootloader\OTA_Bootloader.axf
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: MBEDTLS_CONFIG_FILE=<mbedtls_config.h>,USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../MBEDTLS/App;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/mbedTLS/include/mbedtls;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Middlewares/Third_Party/mbedTLS/include;../Drivers/CMSIS/Include;..\Drivers\BSP\Boot;..\Drivers\BSP\Flash;..\Drivers\BSP\Uart;..\Drivers\BSP\W25Q64;..\Drivers\BSP\Ymodem;..\third_party\HDiffPatch;..\third_party\HDiffPatch\libHDiffPatch\HPatchLite;..\third_party\tinyuz\decompress;..\Drivers\BSP
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c rng.c spi.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Application/User/MBEDTLS/Target
    ../MBEDTLS/Target/: hardware_rng.c
  group Application/User/MBEDTLS/App
    ../MBEDTLS/App/: mbedtls.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_rng.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/mbedTLS
    ../Middlewares/Third_Party/mbedTLS/library/: aes.c asn1parse.c asn1write.c base64.c bignum.c camellia.c chacha20.c chachapoly.c cipher.c cipher_wrap.c ctr_drbg.c dhm.c ecdh.c ecdsa.c ecp.c ecp_curves.c entropy.c entropy_poll.c gcm.c hkdf.c md.c md_wrap.c memory_buffer_alloc.c oid.c pem.c pk.c pkparse.c pk_wrap.c platform.c platform_util.c poly1305.c rsa_internal.c sha256.c ssl_ciphersuites.c ssl_cli.c ssl_tls.c version_features.c x509.c x509_crt.c
    ../Middlewares/Third_Party/mbedTLS/include/: CMakeLists.txt
  group Drivers/BSP
    ../Drivers/BSP/Boot/: Boot.c Boot.h BootCrypto.c BootCrypto.h BootDelta.c BootDelta.h BootOta.c BootOta.h
    ../Drivers/BSP/Flash/: Flash.c Flash.h
    ../Drivers/BSP/Uart/: Uart.c Uart.h
    ../Drivers/BSP/W25Q64/: W25Q64.c W25Q64.h
    ../Drivers/BSP/Ymodem/: Ymodem.c Ymodem.h
    ../Drivers/BSP/: Log.h
    ../third_party/HDiffPatch/libHDiffPatch/HPatchLite/: hpatch_lite.c
    ../third_party/tinyuz/decompress/: tuz_dec.c
software components: CMSIS:CORE 4.3.0
